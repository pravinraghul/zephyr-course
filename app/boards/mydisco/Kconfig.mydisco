## app/boards/mydisco/board.yml
```yaml
board:
  name: mydisco
  full_name: MyDisco
  vendor: st
  socs:
    - name: stm32f429xx
```
